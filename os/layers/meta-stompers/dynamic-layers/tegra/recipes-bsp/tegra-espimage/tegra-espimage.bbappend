# The ESP archive is shipped in the swupdate bundle.
IMAGE_FSTYPES:append = " tar.gz"
