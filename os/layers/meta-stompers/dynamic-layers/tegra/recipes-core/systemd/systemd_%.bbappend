# systemd-pstore moves kernel panic logs from ramoops into the journal.
PACKAGECONFIG:append = " pstore"
