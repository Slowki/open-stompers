# systemd-repart creates the data partition on first boot.
PACKAGECONFIG:append = " repart openssl"
